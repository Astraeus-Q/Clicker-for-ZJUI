<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\oled_key_test.ewp</path>
  </project>
  <batchBuild />
</workspace>
